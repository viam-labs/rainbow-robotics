Commit message: fix joint orientation; clearer cancel message

File: arm/rb10_1300e.urdf (robot description, URDF)
Before this commit: robot rb10_1300e, 8 links, 7 joints
Joints:
- joint tcp_joint: origin xyz=0 -0.1153 0 rpy=0 0 0 -> xyz=0 -0.1153 0 rpy=1.5707963267948966 0 0
